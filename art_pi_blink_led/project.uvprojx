# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: RT_USING_ARM_LIBC, USE_HAL_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, STM32H750xx
  c include: applications;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;board;board\port;board\CubeMX_Config\Core\Inc;board\stm32cubeMX;libraries\drivers;libraries\drivers\include;libraries\drivers\include\config;rt-thread\components\fal\inc;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\finsh;packages\gt9147-v1.1.0\inc;.;rt-thread\include;packages\LVGL-v8.3.11\src;packages\LVGL-v8.3.11\src\core;packages\LVGL-v8.3.11\src\draw;packages\LVGL-v8.3.11\src\extra;packages\LVGL-v8.3.11\src\font;packages\LVGL-v8.3.11\src\hal;packages\LVGL-v8.3.11\src\misc;packages\LVGL-v8.3.11\src\widgets;packages\LVGL-v8.3.11\src\draw\arm2d;packages\LVGL-v8.3.11\src\draw\renesas;packages\LVGL-v8.3.11\src\draw\sdl;packages\LVGL-v8.3.11\src\draw\stm32_dma2d;packages\LVGL-v8.3.11\src\draw\sw;packages\LVGL-v8.3.11\src\draw\swm341_dma2d;packages\LVGL-v8.3.11\src\draw\nxp\pxp;packages\LVGL-v8.3.11\src\draw\nxp\vglite;packages\LVGL-v8.3.11\src\extra\layouts;packages\LVGL-v8.3.11\src\extra\libs;packages\LVGL-v8.3.11\src\extra\others;packages\LVGL-v8.3.11\src\extra\themes;packages\LVGL-v8.3.11\src\extra\widgets;packages\LVGL-v8.3.11\src\extra\layouts\flex;packages\LVGL-v8.3.11\src\extra\layouts\grid;packages\LVGL-v8.3.11\src\extra\libs\bmp;packages\LVGL-v8.3.11\src\extra\libs\ffmpeg;packages\LVGL-v8.3.11\src\extra\libs\freetype;packages\LVGL-v8.3.11\src\extra\libs\fsdrv;packages\LVGL-v8.3.11\src\extra\libs\gif;packages\LVGL-v8.3.11\src\extra\libs\png;packages\LVGL-v8.3.11\src\extra\libs\qrcode;packages\LVGL-v8.3.11\src\extra\libs\rlottie;packages\LVGL-v8.3.11\src\extra\libs\sjpg;packages\LVGL-v8.3.11\src\extra\libs\tiny_ttf;packages\LVGL-v8.3.11\src\extra\others\fragment;packages\LVGL-v8.3.11\src\extra\others\gridnav;packages\LVGL-v8.3.11\src\extra\others\ime;packages\LVGL-v8.3.11\src\extra\others\imgfont;packages\LVGL-v8.3.11\src\extra\others\monkey;packages\LVGL-v8.3.11\src\extra\others\msg;packages\LVGL-v8.3.11\src\extra\others\snapshot;packages\LVGL-v8.3.11\src\extra\themes\basic;packages\LVGL-v8.3.11\src\extra\themes\default;packages\LVGL-v8.3.11\src\extra\themes\mono;packages\LVGL-v8.3.11\src\extra\widgets\animimg;packages\LVGL-v8.3.11\src\extra\widgets\calendar;packages\LVGL-v8.3.11\src\extra\widgets\chart;packages\LVGL-v8.3.11\src\extra\widgets\colorwheel;packages\LVGL-v8.3.11\src\extra\widgets\imgbtn;packages\LVGL-v8.3.11\src\extra\widgets\keyboard;packages\LVGL-v8.3.11\src\extra\widgets\led;packages\LVGL-v8.3.11\src\extra\widgets\list;packages\LVGL-v8.3.11\src\extra\widgets\menu;packages\LVGL-v8.3.11\src\extra\widgets\meter;packages\LVGL-v8.3.11\src\extra\widgets\msgbox;packages\LVGL-v8.3.11\src\extra\widgets\span;packages\LVGL-v8.3.11\src\extra\widgets\spinbox;packages\LVGL-v8.3.11\src\extra\widgets\spinner;packages\LVGL-v8.3.11\src\extra\widgets\tabview;packages\LVGL-v8.3.11\src\extra\widgets\tileview;packages\LVGL-v8.3.11\src\extra\widgets\win;packages\LVGL-v8.3.11\env_support\rt-thread;libraries\samples;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\STM32H750XBHx\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    rt-thread/components/libc/compilers/common/: time.c stdlib.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c showmem.c div0.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_dev.c i2c-bit-ops.c i2c_core.c
    rt-thread/components/drivers/ipc/: ringbuffer.c waitqueue.c completion.c pipe.c ringblk_buf.c dataqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    board/stm32cubeMX/: drv_stm32cebeMX.c
    board/: drv_mpu.c board.c
    board/port/: filesystem.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    libraries/drivers/: drv_wlan.c drv_spi_flash.c drv_soft_i2c.c drv_sdio.c drv_sdram.c drv_lcd.c drv_gpio.c drv_spi.c drv_common.c drv_usart.c
  group Fal
    rt-thread/components/fal/src/: fal_partition.c fal.c fal_rtt.c fal_flash.c
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_fs.c dfs_posix.c dfs_file.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group Finsh
    rt-thread/components/finsh/: shell.c cmd.c msh_file.c msh.c
  group Kernel
    rt-thread/src/: idle.c irq.c object.c thread.c memheap.c scheduler.c ipc.c clock.c components.c kservice.c mempool.c timer.c device.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dma_ex.c stm32h7xx_hal.c stm32h7xx_hal_sram.c stm32h7xx_hal_comp.c stm32h7xx_hal_i2c.c stm32h7xx_hal_gpio.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_spi.c stm32h7xx_hal_crc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_cec.c stm32h7xx_hal_usart.c stm32h7xx_hal_cryp.c stm32h7xx_hal_mdma.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_nor.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_rng.c stm32h7xx_hal_pwr.c stm32h7xx_hal_i2c_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_qspi.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    ./libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dma2d.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_ltdc.c
